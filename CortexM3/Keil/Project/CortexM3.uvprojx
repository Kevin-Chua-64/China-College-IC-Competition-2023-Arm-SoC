# Keil uVision project CortexM3.uvprojx, settings and files
target CortexM3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CortexM3
  AfterMake: fromelf -cvf .\Objects\CortexM3.axf --vhx --32x1 -o .\Objects\image.hex
  AfterMake: fromelf -cvf .\Objects\CortexM3.axf -o .\Objects\image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  c misc: --diag_suppress=47,223
  c include: ..\Software\Core\CMSIS;..\Software\Core\Device\Include;..\Software\User\Func
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Software/Core/CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h
    ../Software/Core/Device/Include/: CortexM3.h CortexM3_driver.h
    ../Software/Core/Device/Source/: CortexM3_driver.c startup_CM3DS.s handler.c system.c Retarget.c
  group User
    ../Software/User/: main.c
    ../Software/User/Func/: basic_draw.c draw.c basic_run.c run.c
